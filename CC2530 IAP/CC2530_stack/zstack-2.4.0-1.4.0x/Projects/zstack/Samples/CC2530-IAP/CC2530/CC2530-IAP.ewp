# IAR project CC2530-IAP.ewp, settings and files
configuration CC2530 Boot Loader (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.CCDefines: HAL_SB_BOOT_CODE; HAL_UART=TRUE; HAL_UART_DMA=0; HAL_UART_ISR=1; HAL_UART_ISR_RX_MAX=254
  ICC8051.CCDiagSuppress: Pe001,Pa010,Pa050
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\Source\drive; ..\Source\iap; ..\Source\shell; ..\Source\sys; ..\Source; source; ..\..\common; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\_COMMON\CC2530; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: sb-boot.xcl
  group (top)
    ../Source/: iap_config.h main.c
  group DRV
    ../Source/drive/: uart.c
  group HAL/Include
    ../../../../../Components/hal/target/CC2530EB/: hal_board_cfg.h hal_dma.h hal_mcu.h hal_types.h
    ../../../../../Components/hal/include/: hal_defs.h hal_flash.h hal_uart.h
  group HAL/Target
    ../../../../../Components/hal/target/CC2530EB/: hal_flash.c
  group IAP
    ../Source/iap/: app_start.c download.c ymodem.c
  group SHELL
    ../Source/shell/: shell.c user_cmd.c
  group SYS
    ../Source/sys/: sys.c
  group Tools
    ../../../ZMain/TI2530DB/: chipcon_cstartup.s51
    ../Source/: interrupt_stubs.s51
    ./: sb-boot.xcl
