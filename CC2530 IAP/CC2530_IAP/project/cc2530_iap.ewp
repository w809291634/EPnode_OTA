# IAR project cc2530_iap.ewp, settings and files
configuration Release (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.CCDiagSuppress: Pa050
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\source\shell; ..\source\drive\uart; ..\source\system\sys; ..\..\CC2530_CONFIG
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
  group (top)
    ../../CC2530_CONFIG/: iap_config.h
    ../source/: main.c
    ../: readme.txt
  group drive
    ../source/drive/uart/: uart.c
  group shell
    ../source/shell/: shell.c user_cmd.c ustdio.c
  group system
    ../source/system/sys/: sys.c
