<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <group>
    <name>drive</name>
    <file>
      <name>$PROJ_DIR$\..\source\drive\uart\uart.c</name>
    </file>
  </group>
  <group>
    <name>iap</name>
  </group>
  <group>
    <name>shell</name>
    <file>
      <name>$PROJ_DIR$\..\source\shell\shell.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\shell\user_cmd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\shell\ustdio.c</name>
    </file>
  </group>
  <group>
    <name>system</name>
    <file>
      <name>$PROJ_DIR$\..\source\system\sys\sys.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\..\CC2530_CONFIG\iap_config.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\source\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\readme.txt</name>
  </file>
</project>


