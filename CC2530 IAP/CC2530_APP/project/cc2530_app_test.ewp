# IAR project cc2530_app_test.ewp, settings and files
configuration Release (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.CCDiagSuppress: Pa050
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\source\shell; ..\source\drive\uart; ..\source\drive\led; ..\source\drive\flash; ..\source\hal_drive; ..\source\iap; ..\source\system\sys; ..\source\system\soft_timer; ..\..\CC2530_CONFIG
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: lnk51ew_cc2530F256_banked.xcl
  group (top)
    ../../CC2530_CONFIG/: iap_config.h
    ./: lnk51ew_cc2530F256_banked.xcl
    ../source/: main.c
    ../: readme.txt
  group drive
    ../source/drive/led/: led.c
    ../source/drive/uart/: uart.c
  group hal_drive
    ../source/hal_drive/: hal_dma.c hal_flash.c
  group system
    ../source/system/soft_timer/: soft_timer.c time.c
    ../source/system/sys/: sys.c
