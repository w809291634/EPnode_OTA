<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CC2530-IAP.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>CC2530-IAP</project>
        <configuration>CC2530 Boot Loader</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


