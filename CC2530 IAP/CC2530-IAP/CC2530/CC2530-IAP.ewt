<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>CC2530 Boot Loader</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <group>
    <name>DRV</name>
    <file>
      <name>$PROJ_DIR$\..\Source\drive\uart.c</name>
    </file>
  </group>
  <group>
    <name>HAL</name>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2530EB\hal_board_cfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_defs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2530EB\hal_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2530EB\hal_mcu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2530EB\hal_types.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_uart.h</name>
      </file>
    </group>
    <group>
      <name>Target</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2530EB\hal_flash.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>IAP</name>
    <file>
      <name>$PROJ_DIR$\..\Source\iap\app_start.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\iap\download.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\iap\ymodem.c</name>
    </file>
  </group>
  <group>
    <name>SHELL</name>
    <file>
      <name>$PROJ_DIR$\..\Source\shell\shell.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\shell\user_cmd.c</name>
    </file>
  </group>
  <group>
    <name>SYS</name>
    <file>
      <name>$PROJ_DIR$\..\Source\sys\sys.c</name>
    </file>
  </group>
  <group>
    <name>Tools</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\ZMain\TI2530DB\chipcon_cstartup.s51</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\interrupt_stubs.s51</name>
    </file>
    <file>
      <name>$PROJ_DIR$\sb-boot.xcl</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\Source\iap_config.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Source\main.c</name>
  </file>
</project>


